## Config.in
```kconfig
config BR2_PACKAGE_VPBUS_GPMC
	bool vpbus_gpmc
	help
	  VirtuAiles parallel bus driver using GPMC
```
